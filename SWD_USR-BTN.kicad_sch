File: SWD_USR-BTN.kicad_sch (KiCad schematic)
At the start: 14 parts, among them J5 SWDB

Commit message: Power domain update
Connections:
- net +3.3VIO renamed +3.3V
